# Keil uVision project Project.uvprojx, settings and files
target SOM-STM32F429IG (ARM-ADS)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: OneElfS=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=25000000,PLL_M=25,PLL_N=360,PLL_P=2,PLL_Q=7
  c include: ..\USER;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\Libraries\CMSIS\Include;..\USER\WM8978;..\USER\helix;..\USER\helix\real;..\USER\helix\pub;..\USER\Audio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group STD_Periph_Drivers
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group helix
    ../USER/helix/: mp3dec.c mp3tabs.c
    ../USER/helix/real/: huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c bitstream.c buffers.c dct32.c dequant.c dqchan.c
    ../USER/helix/real/arm/: asmmisc.s asmpoly_thumb2.s
  group Audio
    ../USER/Audio/: mp3_audio.c
  group WM8978
    ../USER/WM8978/: wav.c audio.c wm8978.c wm8978_i2c.c
  group User
    ../USER/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Doc
    ../: readme.txt
